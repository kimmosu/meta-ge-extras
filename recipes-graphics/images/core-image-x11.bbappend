IMAGE_CLASSES += "image_types_fsl"
IMAGE_FSTYPES += "ext3"

